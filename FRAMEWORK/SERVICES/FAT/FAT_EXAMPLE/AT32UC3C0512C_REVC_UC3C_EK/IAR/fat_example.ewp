# IAR project fat_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32allahn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3C_EK; LITTLE_ENDIAN_MCU=FALSE
  ICCAVR32.CCIncludePath2: ..\..\..\..\..\BOARDS\; ..\..\..\..\..\UTILS\; ..\..\..\..\..\UTILS\DEBUG\; ..\..\..\..\..\UTILS\PREPROCESSOR\; ..\..\..\..\..\DRIVERS\GPIO\; ..\..\..\..\..\DRIVERS\USART\; ..\..\..\..\..\DRIVERS\SPI\; ..\..\..\..\..\DRIVERS\PM\; ..\..\..\..\..\DRIVERS\SCIF\; ..\..\..\..\..\DRIVERS\FLASHC\; ..\..\..\..\..\COMPONENTS\MEMORY\DATA_FLASH\AT45DBX\; ..\..\..\..\MEMORY\CTRL_ACCESS; ..\..\..\; ..\..\
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 0
  ICCAVR32.CCOptStrategy: 0
  AAVR32.AIncludePaths: ..\..\..\..\..\UTILS\; ..\..\..\..\..\UTILS\PREPROCESSOR\
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\..\..\..\..\UTILS\LINKER_SCRIPTS\AT32UC3C\0512C\IAR\lnkuc3c0512c.xcl
  group (top)
    ../../: fat_example.c
  group FAT
    ../../../: fat.c fat_unusual.c file.c navigation.c
  group Memory
    ../../../../../COMPONENTS/MEMORY/DATA_FLASH/AT45DBX/: at45dbx.c at45dbx_mem.c
    ../../../../MEMORY/CTRL_ACCESS/: ctrl_access.c
    ../../../../../DRIVERS/SPI/: spi.c
  group Support
    ../../../../../DRIVERS/FLASHC/: flashc.c
    ../../../../../DRIVERS/GPIO/: gpio.c
    ../../../../../BOARDS/UC3C_EK/: led.c
    ../../../../../DRIVERS/PM/: pm_uc3c.c power_clocks_lib.c
    ../../../../../UTILS/DEBUG/: print_funcs.c
    ../../../../../DRIVERS/SCIF/: scif_uc3c.c
    ../../../../USB/CLASS/DFU/EXAMPLES/ISP/AT32UC3C0512C_REVC/: trampoline.s82
    ../../../../../DRIVERS/USART/: usart.c
