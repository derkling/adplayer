# IAR project jpg_ijg-at32ucr2.ewp, settings and files
configuration speed_opt (AVR32)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32allan.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: NDEBUG; _DLIB_FILE_DESCRIPTOR=1
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ..\..\..\..\..\SERVICES\PICTURE\JPG\IJG\
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 2
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnk0t.xcl
configuration size_opt (AVR32)
  as the first configuration, except:
  ICCAVR32.CCOptStrategy: 1
configuration balanced_opt (AVR32)
  as the first configuration, except:
  ICCAVR32.CCOptStrategy: 0
  group COMLIBSRC
    ../../../../../SERVICES/PICTURES/JPG/IJG/: jcomapi.c jerror.c jmemmgr.c jutils.c
  group DLIBSRC
    ../../../../../SERVICES/PICTURES/JPG/IJG/: jdapimin.c jdapistd.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdphuff.c jdpostct.c jdsample.c jdtrans.c jidctflt.c jidctfst.c jidctint.c jidctred.c jquant1.c jquant2.c
  group SYSDEPSRC
    ../../../../../SERVICES/PICTURES/JPG/IJG/: jmemnobs.c
