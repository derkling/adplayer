# IAR project libdrivers-at32uc3a3.ewp, settings and files
configuration Release (AVR32)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32allaf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=USER_BOARD; __AT32UC3A3256__
  ICCAVR32.CCIncludePath2: ..\..\..\..\..\UTILS\; ..\..\..\..\..\UTILS\PREPROCESSOR\; ..\..\..\..\..\BOARDS\; ..\..\..\..\..\DRIVERS\ADC\; ..\..\..\..\..\DRIVERS\EIC\; ..\..\..\..\..\DRIVERS\FLASHC\; ..\..\..\..\..\DRIVERS\GPIO\; ..\..\..\..\..\DRIVERS\INTC\; ..\..\..\..\..\DRIVERS\PDCA\; ..\..\..\..\..\DRIVERS\PM\; ..\..\..\..\..\DRIVERS\RTC\; ..\..\..\..\..\DRIVERS\SSC\I2S\; ..\..\..\..\..\DRIVERS\TC\; ..\..\..\..\..\DRIVERS\TWIM\; ..\..\..\..\..\DRIVERS\TWIS\; ..\..\..\..\..\DRIVERS\USART\; ..\..\..\..\..\DRIVERS\WDT\
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 0
  ICCAVR32.CCOptStrategy: 2
  AAVR32.ADefines: BOARD=USER_BOARD
  AAVR32.AIncludePaths: ..\..\..\..\..\UTILS\; ..\..\..\..\..\UTILS\PREPROCESSOR\
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnk0t.xcl
configuration speed_opt (AVR32)
  as the first configuration, except:
  ICCAVR32.CCIncludePath2: ..\..\..\..\..\UTILS\; ..\..\..\..\..\UTILS\PREPROCESSOR\; ..\..\..\..\..\BOARDS\; ..\..\..\..\..\DRIVERS\ADC\; ..\..\..\..\..\DRIVERS\EIC\; ..\..\..\..\..\DRIVERS\FLASHC\; ..\..\..\..\..\DRIVERS\GPIO\; ..\..\..\..\..\DRIVERS\INTC\; ..\..\..\..\..\DRIVERS\CPU\MPU\; ..\..\..\..\..\DRIVERS\PDCA\; ..\..\..\..\..\DRIVERS\PM\; ..\..\..\..\..\DRIVERS\RTC\; ..\..\..\..\..\DRIVERS\SSC\I2S\; ..\..\..\..\..\DRIVERS\SSC\USART\; ..\..\..\..\..\DRIVERS\TC\; ..\..\..\..\..\DRIVERS\TWIM\; ..\..\..\..\..\DRIVERS\TWIS\; ..\..\..\..\..\DRIVERS\USART\; ..\..\..\..\..\DRIVERS\WDT\
  ICCAVR32.CCOptLevel: 3
configuration size_opt (AVR32)
  as the first configuration, except:
  ICCAVR32.CCIncludePath2: as above
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
configuration balanced_opt (AVR32)
  as the first configuration, except:
  ICCAVR32.CCIncludePath2: as above
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 0
  group driver
    ../../../../../DRIVERS/ADC/: adc.c
    ../../../../../DRIVERS/EIC/: eic.c
    ../../../../../DRIVERS/FLASHC/: flashc.c
    ../../../../../DRIVERS/GPIO/: gpio.c
    ../../../../../DRIVERS/INTC/: intc.c
    ../../../../../DRIVERS/PDCA/: pdca.c
    ../../../../../DRIVERS/PM/: pm.c pm_conf_clocks.c power_clocks_lib.c
    ../../../../../DRIVERS/RTC/: rtc.c
    ../../../../../DRIVERS/SPI/: spi.c
    ../../../../../DRIVERS/SSC/I2S/: ssc_i2s.c
    ../../../../../DRIVERS/TC/: tc.c
    ../../../../../DRIVERS/TWIM/: twim.c
    ../../../../../DRIVERS/TWIMS/: twims.c
    ../../../../../DRIVERS/USART/: usart.c
    ../../../../../DRIVERS/WDT/: wdt.c
