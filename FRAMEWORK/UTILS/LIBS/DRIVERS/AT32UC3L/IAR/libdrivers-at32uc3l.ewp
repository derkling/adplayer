# IAR project libdrivers-at32uc3l.ewp, settings and files
configuration Release (AVR32)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32allaf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=USER_BOARD
  ICCAVR32.CCDiagSuppress: Pe193
  ICCAVR32.CCIncludePath2: ..\..\..\..\..\UTILS\; ..\..\..\..\..\UTILS\PREPROCESSOR\; ..\..\..\..\..\BOARDS\; ..\..\..\..\..\DRIVERS\ACIFB\; ..\..\..\..\..\DRIVERS\ADCIFB\; ..\..\..\..\..\DRIVERS\FLASHCDW\; ..\..\..\..\..\DRIVERS\CPU\MPU\; ..\..\..\..\..\DRIVERS\GPIO\; ..\..\..\..\..\DRIVERS\INTC\; ..\..\..\..\..\DRIVERS\PDCA\; ..\..\..\..\..\DRIVERS\PM\; ..\..\..\..\..\DRIVERS\PWMA\; ..\..\..\..\..\DRIVERS\SCIF\; ..\..\..\..\..\DRIVERS\TC\; ..\..\..\..\..\DRIVERS\TWIM\; ..\..\..\..\..\DRIVERS\TWIS\; ..\..\..\..\..\DRIVERS\USART\
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 0
  ICCAVR32.CCOptStrategy: 2
  AAVR32.ADefines: BOARD=USER_BOARD
  AAVR32.AIncludePaths: ..\..\..\..\..\UTILS\; ..\..\..\..\..\UTILS\PREPROCESSOR\
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnk0t.xcl
configuration speed_opt (AVR32)
  as the first configuration, except:
  ICCAVR32.CCIncludePath2: ..\..\..\..\..\UTILS\; ..\..\..\..\..\UTILS\PREPROCESSOR\; ..\..\..\..\..\BOARDS\; ..\..\..\..\..\DRIVERS\ACIFB\; ..\..\..\..\..\DRIVERS\ADCIFB\; ..\..\..\..\..\DRIVERS\FLASHCDW\; ..\..\..\..\..\DRIVERS\GPIO\; ..\..\..\..\..\DRIVERS\INTC\; ..\..\..\..\..\DRIVERS\CPU\MPU\; ..\..\..\..\..\DRIVERS\PDCA\; ..\..\..\..\..\DRIVERS\PM\; ..\..\..\..\..\DRIVERS\PWMA\; ..\..\..\..\..\DRIVERS\SCIF\; ..\..\..\..\..\DRIVERS\TC\; ..\..\..\..\..\DRIVERS\TWIM\; ..\..\..\..\..\DRIVERS\TWIS\; ..\..\..\..\..\DRIVERS\USART\
  ICCAVR32.CCOptLevel: 3
configuration size_opt (AVR32)
  as the first configuration, except:
  ICCAVR32.CCIncludePath2: as above
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
configuration balanced_opt (AVR32)
  as the first configuration, except:
  ICCAVR32.CCIncludePath2: as above
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 0
  group driver
    ../../../../../DRIVERS/ACIFB/: acifb.c
    ../../../../../DRIVERS/ADCIFB/: adcifb.c
    ../../../../../DRIVERS/FLASHCDW/: flashcdw.c
    ../../../../../DRIVERS/GPIO/: gpio.c
    ../../../../../DRIVERS/INTC/: intc.c
    ../../../../../DRIVERS/CPU/MPU/: mpu.c
    ../../../../../DRIVERS/PDCA/: pdca.c
    ../../../../../DRIVERS/PM/: pm_uc3l.c power_clocks_lib.c
    ../../../../../DRIVERS/PWMA/: pwma.c
    ../../../../../DRIVERS/SCIF/: scif_uc3l.c
    ../../../../../DRIVERS/SPI/: spi.c
    ../../../../../DRIVERS/TC/: tc.c
    ../../../../../DRIVERS/TWIM/: twim.c
    ../../../../../DRIVERS/TWIS/: twis.c
    ../../../../../DRIVERS/USART/: usart.c
