<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\libdrivers-at32uc3a.ewp</path>
  </project>
  <batchBuild/>
</workspace>


