# IAR project libdrivers-at32uc3c.ewp, settings and files
configuration Release (AVR32)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32allasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=USER_BOARD
  ICCAVR32.CCIncludePath2: ..\..\..\..\..\UTILS\; ..\..\..\..\..\UTILS\PREPROCESSOR\; ..\..\..\..\..\BOARDS\; ..\..\..\..\..\DRIVERS\ACIFA\; ..\..\..\..\..\DRIVERS\ADCIFA\; ..\..\..\..\..\DRIVERS\AST\; ..\..\..\..\..\DRIVERS\CPU\CYCLE_COUNTER\; ..\..\..\..\..\DRIVERS\DACIFB\; ..\..\..\..\..\DRIVERS\EIC\; ..\..\..\..\..\DRIVERS\FLASHC\; ..\..\..\..\..\DRIVERS\GPIO\; ..\..\..\..\..\DRIVERS\INTC\; ..\..\..\..\..\DRIVERS\MDMA\; ..\..\..\..\..\DRIVERS\PDCA\; ..\..\..\..\..\DRIVERS\PEVC\; ..\..\..\..\..\DRIVERS\PM\; ..\..\..\..\..\DRIVERS\PWM\; ..\..\..\..\..\DRIVERS\QDEC\; ..\..\..\..\..\DRIVERS\SCIF\; ..\..\..\..\..\DRIVERS\SPI\; ..\..\..\..\..\DRIVERS\SSC\I2S\; ..\..\..\..\..\DRIVERS\TC\; ..\..\..\..\..\DRIVERS\TWIM\; ..\..\..\..\..\DRIVERS\USART\
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 0
  ICCAVR32.CCOptStrategy: 2
  AAVR32.ADefines: BOARD=USER_BOARD
  AAVR32.AIncludePaths: ..\..\..\..\..\UTILS\; ..\..\..\..\..\UTILS\PREPROCESSOR\
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnk0t.xcl
configuration speed_opt (AVR32)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32allahf.h
  ICCAVR32.CCOptLevel: 3
configuration size_opt (AVR32)
  as the first configuration, except:
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
configuration balanced_opt (AVR32)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32allahf.h
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 0
  group driver
    ../../../../../DRIVERS/ACIFA/: acifa.c
    ../../../../../DRIVERS/ADCIFA/: adcifa.c
    ../../../../../DRIVERS/AST/: ast.c
    ../../../../../DRIVERS/DACIFB/: dacifb.c
    ../../../../../DRIVERS/EIC/: eic.c
    ../../../../../DRIVERS/FLASHC/: flashc.c
    ../../../../../DRIVERS/GPIO/: gpio.c
    ../../../../../DRIVERS/INTC/: intc.c
    ../../../../../DRIVERS/MDMA/: mdma.c
    ../../../../../DRIVERS/PDCA/: pdca.c
    ../../../../../DRIVERS/PEVC/: pevc.c
    ../../../../../DRIVERS/PM/: pm_uc3c.c power_clocks_lib.c
    ../../../../../DRIVERS/PWM/: pwm4.c
    ../../../../../DRIVERS/QDEC/: qdec.c
    ../../../../../DRIVERS/SCIF/: scif_uc3c.c
    ../../../../../DRIVERS/SPI/: spi.c
    ../../../../../DRIVERS/SSC/I2S/: ssc_i2s.c
    ../../../../../DRIVERS/TC/: tc.c
    ../../../../../DRIVERS/TWIM/: twim.c
    ../../../../../DRIVERS/USART/: usart.c
