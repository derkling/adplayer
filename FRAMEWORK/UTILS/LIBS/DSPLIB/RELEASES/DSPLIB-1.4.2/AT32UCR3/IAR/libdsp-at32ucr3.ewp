# IAR project libdsp-at32ucr3.ewp, settings and files
configuration dspspeed_opt (AVR32)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32allan.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x2000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: NDEBUG; DSP_OPTIMIZATION=DSP_OPTI_SPEED
  ICCAVR32.CCIncludePath2: ..\..\..\..\..\..\..\UTILS\; ..\..\..\..\..\..\..\UTILS\PREPROCESSOR\; ..\..\..\..\..\..\..\SERVICES\DSPLIB\INCLUDE\; ..\..\..\..\..\..\..\SERVICES\DSPLIB\GENERIC\BASIC\FILTERING\; ..\..\..\..\..\..\..\SERVICES\DSPLIB\GENERIC\BASIC\OPERATORS\; ..\..\..\..\..\..\..\SERVICES\DSPLIB\GENERIC\BASIC\SIGNAL_GENERATION\; ..\..\..\..\..\..\..\SERVICES\DSPLIB\GENERIC\BASIC\TRANSFORMS\; ..\..\..\..\..\..\..\SERVICES\DSPLIB\GENERIC\BASIC\VECTORS\; ..\..\..\..\..\..\..\SERVICES\DSPLIB\GENERIC\BASIC\WINDOWING\
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 2
  AAVR32.AIncludePaths: ..\..\..\..\..\..\..\UTILS\; ..\..\..\..\..\..\..\UTILS\PREPROCESSOR\; ..\..\..\..\..\..\..\SERVICES\DSPLIB\INCLUDE\; ..\..\..\..\..\..\..\SERVICES\DSPLIB\GENERIC\BASIC\FILTERING\
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnk0t.xcl
configuration dspsize_opt (AVR32)
  as the first configuration, except:
  ICCAVR32.CCDefines: NDEBUG; DSP_OPTIMIZATION=DSP_OPTI_SIZE
  ICCAVR32.CCOptStrategy: 1
configuration dspaccuracy_opt (AVR32)
  as the first configuration, except:
  ICCAVR32.CCDefines: NDEBUG; DSP_OPTIMIZATION=DSP_OPTI_ACCURACY
configuration dspaccandsize_opt (AVR32)
  as the first configuration, except:
  ICCAVR32.CCDefines: NDEBUG; DSP_OPTIMIZATION=DSP_OPTI_ACC_AND_SIZE
  ICCAVR32.CCOptStrategy: 1
  group AT32UC/BASIC/FILTERING
    ../../../../../../../SERVICES/DSPLIB/AT32UC/BASIC/FILTERING/: filt_dsp16_iir_at32uc.c filt_dsp16_iirpart_at32uc.c filt_dsp16_lms_at32uc.s82 filt_dsp16_nlms_at32uc.s82 filt_dsp32_lms_at32uc.c filt_dsp32_lms_fir_at32uc.s82 filt_dsp32_nlms_at32uc.c filt_dsp32_nlms_fir_at32uc.s82
  group AT32UC/BASIC/OPERATORS
    ../../../../../../../SERVICES/DSPLIB/AT32UC/BASIC/OPERATORS/: op_dsp16_ln_at32uc.c op_dsp16_sqrt_at32uc.c
  group AT32UC/BASIC/TRANSFORMS
    ../../../../../../../SERVICES/DSPLIB/AT32UC/BASIC/TRANSFORMS/: trans_dsp16_complex_fft_at32uc.c trans_dsp16_complex_ifft_at32uc.c trans_dsp16_real_complex_fft_at32uc.c
  group AT32UC/BASIC/VECTORS
    ../../../../../../../SERVICES/DSPLIB/AT32UC/BASIC/VECTORS/: vect_dsp16_add_at32uc.c vect_dsp16_complex_conj_at32uc.c vect_dsp16_convpart_at32uc.c vect_dsp16_dotdiv_at32uc.c vect_dsp16_dotmul_at32uc.c vect_dsp16_neg_at32uc.c vect_dsp16_realdiv_at32uc.c vect_dsp16_realmul_at32uc.c vect_dsp16_sub_at32uc.c vect_dsp32_add_at32uc.c vect_dsp32_convpart_at32uc.c vect_dsp32_max_at32uc.c vect_dsp32_min_at32uc.c vect_dsp32_neg_at32uc.c vect_dsp32_realmul_at32uc.c vect_dsp32_sub_at32uc.c
  group AT32UC/BASIC/WINDOWING
    ../../../../../../../SERVICES/DSPLIB/AT32UC/BASIC/WINDOWING/: win_dsp16_rect_at32uc.c win_dsp32_rect_at32uc.c
  group GENERIC/ADVANCED/ADPCM
    ../../../../../../../SERVICES/DSPLIB/GENERIC/ADVANCED/ADPCM/: adpcm.c
  group GENERIC/ADVANCED/RESAMPLING
    ../../../../../../../SERVICES/DSPLIB/GENERIC/ADVANCED/RESAMPLING/: dsp16_resampling.c
  group GENERIC/BASIC/FILTERING
    ../../../../../../../SERVICES/DSPLIB/GENERIC/BASIC/FILTERING/: dsp16_filt_interpolation.c dsp16_filt_interpolation_coefsort.c filt_dsp16_iir.c filt_dsp16_iirpart.c filt_dsp16_lms.c filt_dsp16_lpfirdesign.c filt_dsp16_nlms.c filt_dsp32_iir.c filt_dsp32_iirpart.c filt_dsp32_lms.c filt_dsp32_nlms.c
  group GENERIC/BASIC/OPERATORS
    ../../../../../../../SERVICES/DSPLIB/GENERIC/BASIC/OPERATORS/: op_dsp16_fix_sqrt.c op_dsp16_kfix_ln.c op_dsp32_fix_sqrt.c op_dsp32_kfix_ln.c op_fix_asin.c op_fix_exp.c op_fix_ln.c op_fix_log10.c op_fix_log2.c op_fix_pow.c op_fix_rand.c op_fix_sin.c op_kfix_cos.c op_kfix_sin.c
  group GENERIC/BASIC/SIGNAL_GENERATION
    ../../../../../../../SERVICES/DSPLIB/GENERIC/BASIC/SIGNAL_GENERATION/: gen_cosinusoidal.c gen_dirac.c gen_diraccomb.c gen_noise.c gen_ramp.c gen_rectangular.c gen_sawtooth.c gen_sinusoidal.c gen_step.c
  group GENERIC/BASIC/TRANSFORMS
    ../../../../../../../SERVICES/DSPLIB/GENERIC/BASIC/TRANSFORMS/: trans_dsp16_complex_fft.c trans_dsp16_complex_ifft.c trans_dsp16_realcomplex_fft.c trans_dsp16_twiddle_factors.c trans_dsp32_realcomplex_fft.c trans_dsp32_twiddle_factors.c
  group GENERIC/BASIC/VECTORS
    ../../../../../../../SERVICES/DSPLIB/GENERIC/BASIC/VECTORS/: vect_convolution.c vect_dsp16_add.c vect_dsp16_add_and_saturate.c vect_dsp16_complex_abs.c vect_dsp16_complex_add.c vect_dsp16_complex_conj.c vect_dsp16_complex_sub.c vect_dsp16_convpart.c vect_dsp16_dotdiv.c vect_dsp16_dotmul.c vect_dsp16_intdiv.c vect_dsp16_intmul.c vect_dsp16_max.c vect_dsp16_min.c vect_dsp16_neg.c vect_dsp16_pow.c vect_dsp16_realadd.c vect_dsp16_realdiv.c vect_dsp16_realmul.c vect_dsp16_realsub.c vect_dsp16_sub.c vect_dsp32_add.c vect_dsp32_add_and_saturate.c vect_dsp32_complex_abs.c vect_dsp32_complex_add.c vect_dsp32_complex_sub.c vect_dsp32_convpart.c vect_dsp32_dotdiv.c vect_dsp32_dotmul.c vect_dsp32_intdiv.c vect_dsp32_intmul.c vect_dsp32_max.c vect_dsp32_min.c vect_dsp32_neg.c vect_dsp32_pow.c vect_dsp32_realadd.c vect_dsp32_realdiv.c vect_dsp32_realmul.c vect_dsp32_realsub.c vect_dsp32_sub.c
  group GENERIC/BASIC/WINDOWING
    ../../../../../../../SERVICES/DSPLIB/GENERIC/BASIC/WINDOWING/: win_bartlett.c win_blackman.c win_dsp16_kaiser.c win_dsp32_kaiser.c win_gauss.c win_hamming.c win_hann.c win_rectangular.c win_welch.c
