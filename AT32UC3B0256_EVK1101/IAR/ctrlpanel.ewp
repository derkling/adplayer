# IAR project ctrlpanel.ewp, settings and files
configuration Release (AVR32)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32allaf.h
  General.GSStackSize: 0x1700
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x2800
  ICCAVR32.CCDefines: BOARD=EVK1101; FREERTOS_USED=1
  ICCAVR32.CCIncludePath2: ..\..\..\..\BOARDS\; ..\..\..\..\UTILS\PREPROCESSOR\; ..\..\..\..\UTILS\; ..\..\..\..\UTILS\DEBUG\; ..\..\..\..\UTILS\LIBS\DRIVERS\AT32UC3B\INCLUDE\; ..\..\..\..\SERVICES\USB\CLASS\DFU\EXAMPLES\ISP\BOOT\; ..\..\..\..\SERVICES\FREERTOS\Source\include\; ..\..\..\..\SERVICES\FREERTOS\Source\portable\IAR\AVR32_UC3\; ..\..\..\..\DRIVERS\USBB\; ..\..\..\..\DRIVERS\USBB\ENUM\; ..\..\..\..\DRIVERS\USBB\ENUM\DEVICE\; ..\..\..\..\DRIVERS\USBB\ENUM\HOST\; ..\..\..\..\SERVICES\FAT\; ..\..\..\..\COMPONENTS\MEMORY\DATA_FLASH\AT45DBX\; ..\..\..\..\COMPONENTS\JOYSTICK\SKRHABE010\; ..\..\..\..\SERVICES\MEMORY\CTRL_ACCESS\; ..\..\..\..\SERVICES\USB\; ..\..\..\..\SERVICES\USB\CLASS\MASS_STORAGE\SCSI_DECODER\; ..\..\..\..\SERVICES\USB\CLASS\MASS_STORAGE\HOST_MEM\; ..\..\CONF\; ..\..\ENUM\DEVICE\; ..\..\SENSORS\; ..\..\ACTUATORS\; ..\..\
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 2
  AAVR32.AIncludePaths: ..\..\..\..\UTILS\; ..\..\..\..\UTILS\PREPROCESSOR\
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\..\..\..\UTILS\LINKER_SCRIPTS\AT32UC3B\0256\IAR\lnkuc3b0256.xcl
  group (top)
    ../../: device_ctrl_panel_task.c device_mass_storage_task.c main.c
    ../../ENUM/DEVICE/: usb_descriptors.c usb_specific_request.c
  group Actuators
    ../../ACTUATORS/: cpled.c
  group Board
    ../../../../BOARDS/EVK1101/: led.c
  group DLIB
    ../../../../SERVICES/FREERTOS/Source/portable/IAR/AVR32_UC3/: read.c write.c
    ../../../../SERVICES/USB/CLASS/DFU/EXAMPLES/ISP/BOOT/: trampoline.s82
  group Drivers/USBB
    ../../../../DRIVERS/USBB/: usb_drv.c
  group Drivers/USBB/Enum
    ../../../../DRIVERS/USBB/ENUM/: usb_task.c
  group Drivers/USBB/Enum/Device
    ../../../../DRIVERS/USBB/ENUM/DEVICE/: usb_device_task.c usb_standard_request.c
  group FreeRTOS/AVR32_UC3
    ../../../../SERVICES/FREERTOS/Source/portable/IAR/AVR32_UC3/: exception.s82 port.c
  group FreeRTOS/Source
    ../../../../SERVICES/FREERTOS/Source/portable/MemMang/: heap_3.c
    ../../../../SERVICES/FREERTOS/Source/: list.c queue.c tasks.c
  group Libraries
    ../../../../UTILS/LIBS/DRIVERS/AT32UC3B/IAR/: libdrivers-at32uc3b-size_opt.r82
  group Memory
    ../../../../SERVICES/MEMORY/CTRL_ACCESS/: ctrl_access.c
  group Memory/AT45DBX
    ../../../../COMPONENTS/MEMORY/DATA_FLASH/AT45DBX/: at45dbx.c at45dbx_mem.c
  group Sensors
    ../../SENSORS/: s_accelerometer.c s_joystick.c s_light.c s_pushb.c s_temperature.c
  group USB Mass Storage
    ../../../../SERVICES/USB/CLASS/MASS_STORAGE/HOST_MEM/: host_mem.c
    ../../../../SERVICES/USB/CLASS/MASS_STORAGE/SCSI_DECODER/: scsi_decoder.c
  group Utils
    ../../../../UTILS/DEBUG/: print_funcs.c
